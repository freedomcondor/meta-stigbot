IMAGE_INSTALL += " avrdude \
"
