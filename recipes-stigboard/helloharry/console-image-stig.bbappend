IMAGE_INSTALL += " helloharry2 \
helloharry \
"
